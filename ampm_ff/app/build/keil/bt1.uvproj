# Keil uVision project bt1.uvproj, settings and files
target AMPM_FF (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ampm_ff +hex
  AfterMake: fromelf --bin --output .\output\ampm_ff.bin .\flash\ampm_ff.axf
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\..\driver\STM32F10x_StdPeriph_Driver\inc;..\..\CMSIS\CM3\CoreSupport;..\..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\inc;..\..\ampm_lib;..\..\driver;..\..\driver\ampm\stm32;..\..\ampm_lib\flash_mem
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group main
    ../../src/: main.c
  group driver
    ../../ampm_lib/lib/: tick.c sys_tick.c
    ../../driver/STM32F10x_StdPeriph_Driver/src/: stm32f10x_iwdg.c stm32f10x_gpio.c stm32f10x_rcc.c
    ../../driver/ampm/stm32/: spi.c
  group CMSIS
    ../../CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Startup
    ../../CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group ampm-ff
    ../../ampm_lib/ampm_ff/: ampm_ff.c ampm_ff_port.c
    ../../ampm_lib/flash_mem/: sst25.c
target AMPM_FF_DEBUG (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: PJ2000ST +hex
  AfterMake: fromelf --bin --output .\debug\output\PJ2000STV2.43.bin .\debug\PJ2000ST.axf
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,DEBUG_MODE,GSM_DEBUG_UART3_NC
  c include: ..\..\driver\STM32F10x_StdPeriph_Driver\inc;..\..\CMSIS\CM3\CoreSupport;..\..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\inc;..\..\ampm_lib;..\..\driver;..\..\ampm_lib\ampm_gsm;..\..\driver\ampm\stm32;..\..\ampm_lib\db;..\..\ampm_lib\flash_mem;..\..\ampm_lib\accelerometer\lis3dh;..\..\ampm_lib\accelerometer\mma7660;..\..\ampm_lib\accelerometer;..\..\ampm_lib\PPP;..\..\ampm_lib\uip;..\..\ampm_lib\uip-ppp-lib;..\..\ampm_lib\ampm_gsm\sms;..\..\ampm_lib\FATFS;..\..\ampm_lib\flash_mem;..\..\ampm_lib\common;..\..\ampm_lib\ftp
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
